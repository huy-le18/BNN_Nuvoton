# Keil uVision project Project_temp.uvproj, settings and files
target Project_temp (MCS-51)
  device: MS51xA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: Project_temp +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\Library\Device\Include;..\Library\StdDriver\inc;..\user_library\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Library
    ../Library/StdDriver/src/: adc.c bod.c common.c delay.c eeprom.c eeprom_sprom.c i2c.c IAP.c IAP_SPROM.c isr.c pwm.c spi.c sys.c timer.c uart.c wdt.c wkt.c
    ../user_library/src/: delay_ms_tm3.c
  group Startup
    ../Library/Startup/Keil/: STARTUP.A51
